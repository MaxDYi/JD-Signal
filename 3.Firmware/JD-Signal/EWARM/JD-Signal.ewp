# IAR project JD-Signal.ewp, settings and files
configuration JD-Signal (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H750xx; _DLIB_FILE_DESCRIPTOR; ARM_MATH_BIG_ENDIAN; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; ARM_MATH_LOOPUNROLL
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS-DSP/Include; ../Drivers/Algorithm; ../Drivers/BodeSetting; ../Drivers/IPort3; ../Drivers/LCD; ../Drivers/LTC6912; ../Drivers/SaveInCSV; ../Drivers/UserInteraction; ../FATFS/Target; ../FATFS/App; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: JD-Signal.hex
  ILINK.IlinkOutputFile: JD-Signal.out
  ILINK.IlinkIcfFile: stm32h750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: write.c main.c gpio.c freertos.c adc.c dac.c dma.c rtc.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Drivers/Algorithm
    ../Drivers/Algorithm/: Algorithm.c
  group Drivers/BodeSetting
    ../Drivers/BodeSetting/: BodeSetting.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/CMSIS-DSP
    ../Drivers/CMSIS-DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../Drivers/CMSIS-DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group Drivers/IPort3
    ../Drivers/IPort3/: IPort3.c
  group Drivers/LCD
    ../Drivers/LCD/: LCD.c ST7789.c
  group Drivers/LTC6912
    ../Drivers/LTC6912/: LTC6912.c
  group Drivers/SaveInCSV
    ../Drivers/SaveInCSV/: SaveInCSV.c SD.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/UserInteraction
    ../Drivers/UserInteraction/: UserInteraction.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
